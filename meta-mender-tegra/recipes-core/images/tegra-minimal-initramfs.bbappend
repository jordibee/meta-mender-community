# I need to add this as per here:
# https://hub.mender.io/t/warrior-tegra-build-cicular-dependencies/757/6
# Migrating to warrior would fix the problem nevertheless...
EXTRA_IMAGEDEPENDS_remove = "u-boot"
